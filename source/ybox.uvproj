# Keil uVision project ybox.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ybox +hex
  c flags: Optimize=9 SizeSpeed=1
  group mian
    ./: STARTUP.A51 main.c
  group lcd
    ./inc/lcd/: font_ascil.h nokia_5110.c nokia_5110.h
  group menu
    ./menu/: menu.c menu.h menu_data.h
  group timer
    ./inc/timer/: timer.c timer.h
  group event
    ./inc/event/: event.c event.h
  group about
    ./about/: about.c about.h about_data.h
  group mine
    ./mine/: mine.c mine.h mine_data.h
